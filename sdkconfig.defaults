## sdkconfig.defaults
```kconfig
CONFIG_ESP_ZB_COORDINATOR=y
CONFIG_ESP_ZB_NETWORK_BACKUP=y
CONFIG_ESP_ZB_TRACE_OPTIONS=y
CONFIG_ESP_ZB_DEBUG_MODE=y
```
